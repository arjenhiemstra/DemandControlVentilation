## sdkconfig.defaults
```kconfig
CONFIG_AUTOSTART_ARDUINO=y
CONFIG_FREERTOS_HZ=1000
CONFIGMBEDTLS_PSK_MODE=y
CONFIG_MBEDTLS_KEY_EXCHANGE_PSK=y
```
